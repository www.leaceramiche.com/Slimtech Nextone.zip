Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], ExchangeRequirement[Architecture]
File name: F:/BIM PGR/BIM LEA/NEXTONE/slimtech nextone/Slimtech Nextone 6 mm.ifc
Time: 2021-01-04T18:33:19
Author: Architect
Organization: Nemetschek Vectorworks, Inc.
Written by: Vectorworks Architect 2021 SP2 R1 (Build 574483) (64-Bit) by Vectorworks, Inc.
Made in: Windows

# IfcSite, Sito standard
RefLatitude: 0, 0, 0; RefLongitude: 0, 0, 0

# IfcBuilding, Edificio standard
Pset_BuildingCommon - SprinklerProtection: no; SprinklerProtectionAutomatic: no; NumberOfStoreys: 1; IsLandmarked: no

# IfcBuildingStorey, Piano 1
In: Edificio standard
Elevation: 0 mm
Pset_BuildingStoreyCommon - EntranceLevel: no; AboveGround: yes; SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2

# IfcCovering: Laminated porcelain stoneware (UGL) (8)
In: Piano 1
Description: Porcelain stoneware tiles; PredefinedType: USERDEFINED; Material: Default
OtherThecnicalFeatures - AntibacterialProperties: Protect - test report available; ApparentDensity: 2,3 - 2,5 g/cm3; ChemicalResistance: LA, HA RESISTANT; CompressionResistance: n/a; CrazingResistance: Pass; DeepAbrasionResistance: 175 mm3; DimensionsLengthAndWidth: ± 0,3 %, max ± 1 mm; DimensionsRectangularity: ± 0,3 %, max ± 1,5 mm; DimensionsStraightness: ± 0,3 %, max ± 0,8 mm; DimensionsSurfaceFlatness: ± 0,4 %, max ± 1,8 mm; DimensionsThickness: ± 5 % ± 0,5mm; ElectricalConductivity: n/a; FrostResistance: Resistant; HardnessMohsScale: n/a; ImpactResistance: n/a; Light ReflectanceValueLRV: On request; LightAndColourFastness: Pass; LinearThermalExpansion: α ≤ 7·10-6 °C-1; ModulusOfRupture: 50 N/mm2; MoistureExpansion: n/a; PhotocatalyticProperties: n/a; StainsResistance: 5 RESISTANT; SurfaceAbrasionResistance: n/a; SurfaceQuality: n/a; ThermalConductivity: 1,3 W/m °K; TotalPorosity: n/a; WaterAbsorption: 0,1%
EnvironmentalSustainability - AsbestosFreeMaterial: yes; CAMCompliantDeclaration: On request (EPD); Ecolabel UE: no; EcolabelCertification: n/a; EMASCertification/Document: https://www.leaceramiche.it/download; EnvironmentalProductDeclarationEPD: yes; EPDDocument: On request; EPDType: Product-Specific Type III EPD; FicheDeDéclarationEnvironnementaleEtSanitaireFDESCertification: n/a; FormaldehydeFreeMaterial: yes; HealthProductDeclarationHPDCertification/self declaration: On request; ISO45001Certification: n/a; ISO50001Certification: n/a; ISO9001Certification: https://www.leaceramiche.it/download; RawMaterialSourceAndExtractionDocument: On request; REACHCompliant: yes; RecyclableProductPackaging: yes; RecycledContentPreconsumerCertification: https://www.leaceramiche.it/download; SolarReflectance_After3YearValue: On request; SolarReflectance_InitialValue: On request; SolarReflectanceCertification: n/a; SolarReflectanceIndexSRICertification: On request; VOCIndoorAirQualityCertification: On request; ZeroVOCMineralBasedProduct: yes
DoP&ProductCertification - BondStrengthAdhesion: NPD; BreakingStrength: ≥ 700 N; CEMarking: yes; CertificateNumber: n/a; DeclarationPerformanceNumber: DOP006LEA; DurabilityExternalUseFreezeThawResistance: Passed; DurabilityForInternalUse: Passed; HarmonizedTechnicalSpecification: EN 14411:2012; Intended Use: Ceramic tiles for internal flooring and internal and external wall applications.; NameAndIdentificationNumberOfNotifiedLaboratory: n/a; ReactionToFire: A1fl/A1; ReleaseOfDangerousSubstanceCadmium: NPD; ReleaseOfDangerousSubstanceLead: NPD; SlipperinessBCRA_Tribometer: μ > 0,40; SlipperinessBOT3000_Tribometer: DCOF ≥ 0.42; SlipperinessBS7976-2_PendulumTester: n/a; SlipperinessDIN51097_RampBarefoot: n/a; SlipperinessDIN51130_RampWithOil: R10; SlipperinessDIN51131_Tribometer: n/a; SlipperinessENV12633_PendulumTester: n/a; SlipperinessXPCENTS16165_RampTest: n/a; SystemOfAssessmentAndVerificationOfCostancyOfPperformance: System 4; Tactility: NPD; TensileStrengthOrModulusOfRupture: 50 N/mm2; ThermalShockResistance: Pass; UNIMark: no; UNIMarkCertification: On request; UniqueIdentificationCodeOfTheProductType: Dry-pressed ceramic tiles,with water absorption Eb<0,5%; UPECmark: no; UPECMarkCertification: n/a
COBie_ServiceLife - ExpectedLife: 50
COBie_EconomicImpactValues - ReplacementCost: 0
COBie_Component - InstallationDate: 31/12/1900 23:59:59; WarrantyStartDate: n/a; TagNumber: n/a; AssetIdentifier: n/a
Pset_CoveringFlooring - HasNonSkidSurface: yes; HasAntiStaticSurface: no
Pset_Condition - AssessmentDate: 31/12/1900 23:59:59; AssessmentCondition: n/a; AssessmentDescription: n/a
Pset_CoveringCommon - Reference: Laminated porcelain stoneware (UGL); AcousticRating: n/a; FlammabilityRating: Class A1 (wall) ; Class A1fl (floor); FragilityRating: n/a; Combustible: no; SurfaceSpreadOfFlame: Class A; Finish: Natural Rectified; IsExternal: no; ThermalTransmittance: 216 W/K/m2; FireRating: Class A1 (wall) ; Class A1fl (floor)
COBie_Asset - AssetType: Fixed
COBie_Specification - NominalWidth: 1200 mm; NominalHeight: 6 mm; Finish: Natural Rectified; Grade: n/a; Material: Porcelain stoneware tile; Constituents: n/a; Features: n/a; AccessibilityPerformance: n/a; CodePerformance: n/a; SustainabilityPerformance: n/a
COBie_Warranty - WarrantyGuarantorParts: n/a; WarrantyDurationParts: 0; WarrantyGuarantorLabor: n/a; WarrantyDurationLabor: 0; WarrantyDescription: n/a
Pset_ManufacturerTypeInformation - GlobalTradeItemNumber: n/a; ModelReference: Slimtech Nextone; Manufacturer: Lea Ceramiche (Panariagroup Industrie Ceramiche S.p.A.); ProductionYear: n/a
Pset_EnvironmentalImpactIndicators - Reference: Laminated porcelain stoneware (UGL); FunctionalUnitReference: 1 mq (m2); Unit: 1 mq (m2); LifeCyclePhase: Manufacture; ExpectedServiceLife: 50 s; TotalPrimaryEnergyConsumptionPerUnit: 225; WaterConsumptionPerUnit: 0.054 m3; HazardousWastePerUnit: 0.00235 g; NonHazardousWastePerUnit: 1.62 g; ClimateChangePerUnit: 10.7 g; AtmosphericAcidificationPerUnit: 0.0254 g; RenewableEnergyConsumptionPerUnit: 46; NonRenewableEnergyConsumptionPerUnit: 179; ResourceDepletionPerUnit: 0.000075 g; InertWastePerUnit: 0 g; RadioactiveWastePerUnit: 0.00393 g; StratosphericOzoneLayerDestructionPerUnit: 0 g; PhotochemicalOzoneFormationPerUnit: 0.00232 g; EutrophicationPerUnit: 0.00358 g
Pset_EnvironmentalImpactValues - TotalPrimaryEnergyConsumption: 0; WaterConsumption: 0 m3; HazardousWaste: 0 g; NonHazardousWaste: 0 g; ClimateChange: 0 g; AtmosphericAcidification: 0 g; RenewableEnergyConsumption: 0; NonRenewableEnergyConsumption: 0; ResourceDepletion: 0 g; InertWaste: 0 g; RadioactiveWaste: 0 g; StratosphericOzoneLayerDestruction: 0 g; PhotochemicalOzoneFormation: 0 g; Eutrophication: 0 g; LeadInTime: 0; Duration: 0; LeadOutTime: 0
Pset_ServiceLife - ServiceLifeDuration: 50; MeanTimeBetweenFailure: n/a
Pset_Warranty - WarrantyIdentifier: n/a; WarrantyStartDate: 31/12/1900 23:59:59; WarrantyEndDate: 31/12/1900 23:59:59; IsExtendedWarranty: no; WarrantyPeriod: n/a; WarrantyContent: n/a; PointOfContact: n/a; Exclusions: n/a
COBie - BarCode: n/a; Category: Pr_35_93_96_19:Ceramic tiles; Description: Stone Effect; DurationUnit: Year; Manufacturer: Lea Ceramiche (Panariagroup Industrie Ceramiche S.p.A.); ModelNumber: n/a; ModelReference: Slimtech Nextone; SerialNumber: n/a; WarrantyDurationUnit: Year
Name | NominalLength (mm) | Shape | Size | Color = ModelLabel | ArticleNumber | Name
Slimtech Nextone Next White Nat Ret 120x260 | 2600 | Rectangular | 1200x2600x6 | Next White | LS6NX30 | Next White Naturale Rettificato120x260
Slimtech Nextone Next Gray Nat Ret 120x260 | 2600 | Rectangular | 1200x2600x6 | Next Gray | LS6NX10 | Next Gray Naturale Rettificato120x260
Slimtech Nextone Next Taupe Nat Ret 120x260 | 2600 | Rectangular | 1200x2600x6 | Next Taupe | LS6NX20 | Next Taupe Naturale Rettificato120x260
Slimtech Nextone Next Dark Nat Ret 120x260 | 2600 | Rectangular | 1200x2600x6 | Next Dark | LS6NX00 | Next Dark Naturale Rettificato120x260
Slimtech Nextone Next White Nat Ret 120x120 | 1200 | Square | 1200x1200x6 | Next White | LS8NX30 | Next White Naturale Rettificato 120x120
Slimtech Nextone Next Gray Nat Ret 120x120 | 1200 | Square | 1200x1200x6 | Next Gray | LS8NX10 | Next Gray Naturale Rettificato120x120
Slimtech Nextone Next Taupe Nat Ret 120x120 | 1200 | Square | 1200x1200x6 | Next Taupe | LS8NX20 | Next Taupe Naturale Rettificato 120x120
Slimtech Nextone Next Dark Nat Ret 120x120 | 1200 | Square | 1200x1200x6 | Next Dark | LS8NX00 | Next Dark Naturale Rettificato120x120
